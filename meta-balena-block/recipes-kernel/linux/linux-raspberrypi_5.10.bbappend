FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://cw2015-battery.cfg"
